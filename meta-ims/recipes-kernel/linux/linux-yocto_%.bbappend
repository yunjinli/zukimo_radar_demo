FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://cma-limit.cfg"